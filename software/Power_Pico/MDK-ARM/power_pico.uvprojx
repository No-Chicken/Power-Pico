# Keil uVision project power_pico.uvprojx, settings and files
target power_pico (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: power_pico +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,LV_CONF_INCLUDE_SIMPLE,POWER_PICO_UI_MODERN=1
  c misc: --locale=english --preinclude=armcc_compat.h
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../BSP/KEY;../BSP/LCD;../BSP/GATE;../BSP/BEEP;../BSP/data_queue;../BSP/PD;../BSP/EEPROM;../Middlewares/LVGL;../Middlewares/LVGL/src;../Middlewares/LVGL/porting;../User/Tasks/Inc;../User/GUI;../User/GUI/common;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\User
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Application/User/Algorithm
    ../User/: user_AdcDataStrategy.c user_CmdStrategy.c
  group Application/User/Tasks
    ../User/Tasks/Src/: user_TasksInit.c user_HardwareInitTask.c user_LVGLTask.c user_KeyTask.c user_MessageTask.c user_PDUFPTask.c
  group Application/User/GUI
    ../User/GUI/common/: lv_lib_pm.c lv_lib_animation.c lv_i18n.c
    ../User/GUI/: ui.c ui_helpers.c
    ../User/GUI/screens/: ui_StartPage.c ui_mainPage.c ui_ChartPage.c ui_SetPage.c ui_PPSPage.c ui_PDFixedPage.c ui_FixedVoltagePage.c ui_PowerPage.c
    ../User/GUI/modern/: ui_palette.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c
  group Drivers/BSP
    ../BSP/LCD/: lcd.c lcd_init.c
    ../BSP/KEY/: key.c
    ../BSP/GATE/: gate.c
    ../BSP/BEEP/: beep.c
    ../BSP/EEPROM/: BL24C02.c
    ../BSP/PD/: FUSB302_UFP.c PD_UFP_Protocol.c fusb302_dev.c fixed_voltage_control.c
    ../BSP/DIAG/: pico_diag.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL/Port
    ../Middlewares/LVGL/porting/: lv_port_disp.c
  group Middlewares/LVGL/Font
    ../User/GUI/font/: ui_font_fixed_voltage_control16.c ui_font_home_label18.c ui_font_instrument17.c ui_font_instrument35.c ui_font_menu_bold17.c ui_font_modern14.c ui_font_modern16.c ui_font_round18.c ui_font_round_complete18.c ui_font_title17.c ui_font_zhongyuan18.c ui_font_zhongyuan20.c ui_font_HeiTi32.c ui_font_HeiTi48.c
    ../Middlewares/LVGL/src/font/: lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_28.c lv_font_montserrat_20.c lv_font_montserrat_22.c
  group Middlewares/LVGL/Img
    ../User/GUI/images/: ui_img_chicken96_png.c
  group Middlewares/LVGL/Src/Core
    ../Middlewares/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/LVGL/src/: lv_init.c
  group Middlewares/LVGL/Src/Font
    ../Middlewares/LVGL/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/LVGL/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/LVGL/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/src/font/: lv_font.c
  group Middlewares/LVGL/Src/Display
    ../Middlewares/LVGL/src/display/: lv_display.c
  group Middlewares/LVGL/Src/Draw
    ../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c
    ../Middlewares/LVGL/src/draw/convert/: lv_draw_buf_convert.c
  group Middlewares/LVGL/Src/Indev
    ../Middlewares/LVGL/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group Middlewares/LVGL/Src/Layout
    ../Middlewares/LVGL/src/layouts/: lv_layout.c
    ../Middlewares/LVGL/src/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/src/layouts/flex/: lv_flex.c
  group Middlewares/LVGL/Src/Libs
    ../Middlewares/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
  group Middlewares/LVGL/Src/Misc
    ../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group Middlewares/LVGL/Src/Osal
    ../Middlewares/LVGL/src/osal/: lv_cmsis_rtos2.c lv_os.c lv_os_none.c
  group Middlewares/LVGL/Src/Stdlib
    ../Middlewares/LVGL/src/stdlib/: lv_mem.c
    ../Middlewares/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group Middlewares/LVGL/Src/Theme
    ../Middlewares/LVGL/src/themes/: lv_theme.c
    ../Middlewares/LVGL/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/LVGL/src/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/src/themes/mono/: lv_theme_mono.c
  group Middlewares/LVGL/Src/Tick
    ../Middlewares/LVGL/src/tick/: lv_tick.c
  group Middlewares/LVGL/Src/Widgets
    ../Middlewares/LVGL/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/src/widgets/spinner/: lv_spinner.c
software components: CMSIS:CORE 5.6.0
